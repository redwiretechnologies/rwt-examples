options:
  parameters:
    author: Toby Flynn
    copyright: 2021 Red Wire Technologies
    generate_options: qt_gui
    id: RWT_FM_Radio
    output_language: python
    title: Red Wire Technologies FM Demo
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: frequency
    outputmsgname: value
    showports: 'False'
    start: '87'
    step: '.1'
    stop: '108'
    value: '107.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    outputmsgname: value
    showports: 'False'
    start: '0.2'
    step: '0.1'
    stop: '2'
    value: '.2'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: volume
    type: float
  states: {}
- name: rwt_source_0
  id: rwt_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(4e5)
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    bypass_enable: 'False'
    correction_enable: 'True'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    filter: ''
    force_reload: 'False'
    freq: frequency*1e6
    gain_mode: manual
    manual_gain: '32.0'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    use_tags: 'True'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://192.168.10.1:50010
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', zeromq_pub_sink_0, '0']
- [rwt_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
