options:
  parameters:
    author: Toby Flynn
    copyright: 2023 Red Wire Technologies
    generate_options: qt_gui
    id: RWT_FM_Radio_Host
    output_language: python
    title: Red Wire Technologies FM Demo
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: '87'
    step: '.1'
    stop: '108'
    value: '103.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0.2'
    step: '0.1'
    stop: '2'
    value: '.2'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rwt_source_0
  id: rwt_source
  parameters:
    address: tcp://192.168.10.1:5555
    auto_filter: 'True'
    bandwidth: int(4e5)
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    bypass_enable: 'False'
    correction_enable: 'True'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    force_reload: 'False'
    freq: frequency*1e6
    gain_mode: manual
    manual_gain: '32.0'
    portno: '29051'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    use_tags: 'True'
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://192.168.10.1:50010
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.10.1:50010
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', zeromq_pub_sink_0, '0']
- [rwt_source_0, '0', analog_fm_demod_cf_0, '0']
- [zeromq_sub_source_0, '0', audio_sink_0, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.6.0-28-gf87ee512
